# Keil uVision project portable-clock.uvproj, settings and files
target portable-clock (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: thermo-hygrometer +hex
  group Source
    ./usr/: main.c ntc_sampling.c
  group libiary
    ./library/: STC32G_ADC.c STC32G_NVIC.c STC32G_Timer.c STC32G_Timer_Isr.c STC32G_GPIO.c STC32G_UART.c STC32G_UART_Isr.c STC32G_CAN.c STC32G_CAN_Isr.c STC32G_Clock.c STC32G_Delay.c STC32G_EEPROM.c STC32G_RTC.c STC32G_RTC_Isr.c STC32G_Compare.c STC32G_Compare_Isr.c
  group hardware
    ./HARDWARE/LCD/: lcd.c lcd_init.c spi.c lcdfont.h pic.h
